Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_HD080L_INT-EN.ifc
Time: 2025-08-05T18:26:09+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1982227_1
Port_1982227_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN:HD080L, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN:HD080L:1982227
In: F00
Type - Material: Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Air Vent Height: 80 mm; B: 277 mm; Base Bracket Distance: 20 mm; Base Flange: 10 mm; Base Flange Radius: 44.45 mm; Chamfer Radius: 43.8 mm; Cone Flange: 20 mm; Cone Flange Radius Bottom: 58 mm; Cone Flange Radius Top: 44 mm; Connection Diameter: 80 mm; Container Height: 1022 mm; DF: 340 mm; Distance Between Brackets: 1200 mm; Distance Between Flanges: 8 mm; DN: 80 mm; Drain Distance: 14 mm; Drain Radius: 16.85 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN; Flange Body: 17 mm; Flange Body Radius: 100 mm; Flange Distance: 102 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 70 mm; Flange Height: 21 mm; h: 525 mm; h1: 620 mm; Handle Offset: 182 mm; LF Radius: 235 mm; L Radius: 185 mm; ND: 80 mm; OD: 88.9 mm; Ring Diameter: 26 mm; Valve Distance: 97 mm; x: 1020 mm; y: 50 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 219 mm; H: 1145 mm; L: 370 mm; LF: 470 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Weld DN080 -High-Flow - Demountable; Article Type: HD080L; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Weld DN080 -High-Flow - Demountable; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811014745; Manufacturer: Spirotech; Manufacturer Art. No.: HD080L; Manufacturer URL: https://www.spirotech.com/8717811014745; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: HD080L; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: HD080L; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Dark Yellow: Color RGB 168-128-048; Grey: Color RGB 128-128-128; Red: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.015 m3/s; Pressure Stage: 0; Volume: 0.037 m3; Weight: 60 kg
Type - Mechanical - Flow - Pressure Drop: 12400 Pa
Type - Visibility - Bracket: no; Flange: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HD080L; sets with these values: 2
Other - Bottom Clearance Safe: 1020 mm; Connector Length: 370 mm; Connector Safe: 185 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN: HD080L; Model Line Width: 370 mm; Top Clearance Safe: 50 mm; Type: HD080L; Type Id: 1982191; Width Service Space: 370 mm
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 1.69845 m2; Maximum Size: 80 mm; Minimum Size: 80 mm; Volume: 0.0439285 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - Flow In: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 1020 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
