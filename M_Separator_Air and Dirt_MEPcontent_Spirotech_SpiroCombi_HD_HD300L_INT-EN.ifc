Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 6f0957dd-03e5-4dcf-9efe-4b98d1b06f86, NumberOfSaves: 0]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_HD300L_INT-EN.ifc
Time: 2025-08-26T15:05:59+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENU) - IFC 23.4.0.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_69632_1
Port_69632_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN:HD300L, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN:HD300L:69632
In: Level 1
Type - Material: Color RGB 128-128-128, Color RGB 198-000-000, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Air Vent Height: 65 mm; B: 10 mm; Base Bracket Distance: 399 mm; Base Flange: 19 mm; Base Flange Radius: 161.95 mm; Chamfer Radius: 122 mm; Cone Flange: 34 mm; Cone Flange Radius Bottom: 180 mm; Cone Flange Radius Top: 161.95 mm; Connection Diameter: 300 mm; Container Height: 3083 mm; DF: 840 mm; Distance Between Brackets: 1600 mm; Distance Between Flanges: 12 mm; DN: 0.00328084 mm; Drain Distance: 24 mm; Drain Radius: 30.15 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN; Flange Body: 24 mm; Flange Body Radius: 230 mm; Flange Distance: 231 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 189 mm; Flange Height: 28 mm; h: 1550 mm; h1: 1640 mm; Handle Offset: 408 mm; LF Radius: 502.5 mm; L Radius: 422.5 mm; ND: 300 mm; OD: 323.8 mm; Ring Diameter: 45 mm; Valve Distance: 220 mm; x: 3070 mm; y: 50 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 610 mm; H: 3190 mm; L: 845 mm; LF: 1005 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Weld DN300-High-Flow - Demountable; Article Type: HD300L; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Weld DN300-High-Flow - Demountable; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; Manufacturer: Spirotech; Manufacturer Art. No.: HD300L; Manufacturer URL: https://www.spirotech.com/products/spirocombi/; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: HD300L; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: HD300L; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Dark Yellow: Color RGB 168-128-048; Grey: Color RGB 128-128-128; Red: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 dm3/s; Nominal Flow Rate: 225 dm3/s; Pressure Stage: 0; Volume: 0.83 m3; Weight: 950 kg
Type - Mechanical - Flow - Pressure Drop: 31200 Pa
Type - Text - Pipe Type Category: M561
Type - Visibility - Bracket: yes; Flange: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HD300L; sets with these values: 2
Other - Bottom Clearance Safe: 3070 mm; Connector Length: 845 mm; Connector Safe: 422.5 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN: HD300L; Model Line Width: 845 mm; Top Clearance Safe: 50 mm; Type: HD300L; Type Id: 69617; Width Service Space: 845 mm
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 11.3422 m2; Maximum Size: 300 mm; Minimum Size: 300 mm; Volume: 0.926561 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 1
Mechanical - Flow In: 0 dm3/s; System Classification: Undefined
Phasing - Phase Created: New Construction
Visibility - Bottom Clearance: 3070 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
