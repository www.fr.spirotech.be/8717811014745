Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_HD200F_INT-EN.ifc
Time: 2025-08-05T18:25:52+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1982219_1
Port_1982219_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN:HD200F, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN:HD200F:1982219
In: F00
Type - Material: Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Air Vent Height: 60 mm; B: 435.5 mm; Base Bracket Distance: 20 mm; Base Flange: 16.5 mm; Base Flange Radius: 109.55 mm; Chamfer Radius: 81.2 mm; Cone Flange: 22 mm; Cone Flange Radius Bottom: 131 mm; Cone Flange Radius Top: 110 mm; Connection Diameter: 200 mm; Container Height: 1885 mm; DF: 580 mm; Distance Between Brackets: 1200 mm; Distance Between Flanges: 10 mm; DN: 200 mm; Drain Distance: 12 mm; Drain Radius: 30.15 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN; Flange Body: 21 mm; Flange Body Radius: 170 mm; Flange Distance: 167 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 134 mm; Flange Height: 26 mm; h: 955 mm; h1: 1040 mm; Handle Offset: 295 mm; LF Radius: 387.5 mm; L Radius: 325 mm; ND: 200 mm; OD: 219.1 mm; Ring Diameter: 45 mm; Valve Distance: 159 mm; x: 1880 mm; y: 50 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 406 mm; H: 1995 mm; L: 650 mm; LF: 775 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Flange DN200 -High-Flow - Demountable; Article Type: HD200F; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Flange DN200 -High-Flow - Demountable; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811002872; Manufacturer: Spirotech; Manufacturer Art. No.: HD200F; Manufacturer URL: https://www.spirotech.com/8717811002872; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: HD200F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: HD200F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Dark Yellow: Color RGB 168-128-048; Grey: Color RGB 128-128-128; Red: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.1 m3/s; Pressure Stage: 16; Volume: 0.23 m3; Weight: 295 kg
Type - Mechanical - Flow - Pressure Drop: 23400 Pa
Type - Visibility - Bracket: no; Flange: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HD200F; sets with these values: 2
Other - Bottom Clearance Safe: 1880 mm; Connector Length: 775 mm; Connector Safe: 387.5 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN: HD200F; Model Line Width: 775 mm; Top Clearance Safe: 50 mm; Type: HD200F; Type Id: 1982175; Width Service Space: 775 mm
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 5.76788 m2; Maximum Size: 200 mm; Minimum Size: 200 mm; Volume: 0.266006 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - Flow In: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 1880 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
