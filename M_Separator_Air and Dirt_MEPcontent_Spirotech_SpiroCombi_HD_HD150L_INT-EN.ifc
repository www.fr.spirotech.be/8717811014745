Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_HD150L_INT-EN.ifc
Time: 2025-08-05T18:25:56+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1982221_1
Port_1982221_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN:HD150L, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN:HD150L:1982221
In: F00
Type - Material: Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Air Vent Height: 80 mm; B: 362.5 mm; Base Bracket Distance: 20 mm; Base Flange: 12 mm; Base Flange Radius: 84.15 mm; Chamfer Radius: 64.8 mm; Cone Flange: 21 mm; Cone Flange Radius Bottom: 99 mm; Cone Flange Radius Top: 84.15 mm; Connection Diameter: 150 mm; Container Height: 1441 mm; DF: 460 mm; Distance Between Brackets: 1200 mm; Distance Between Flanges: 10 mm; DN: 150 mm; Drain Distance: 14 mm; Drain Radius: 16.85 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN; Flange Body: 19 mm; Flange Body Radius: 142.5 mm; Flange Distance: 134 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 106 mm; Flange Height: 24 mm; h: 745 mm; h1: 825 mm; Handle Offset: 299 mm; LF Radius: 317.5 mm; L Radius: 262.5 mm; ND: 150 mm; OD: 168.3 mm; Ring Diameter: 45 mm; Valve Distance: 119 mm; x: 1450 mm; y: 50 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 324 mm; H: 1570 mm; L: 525 mm; LF: 635 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Weld DN150-High-Flow - Demountable; Article Type: HD150L; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Weld DN150-High-Flow - Demountable; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811043448; Manufacturer: Spirotech; Manufacturer Art. No.: HD150L; Manufacturer URL: https://www.spirotech.com/8717811043448; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: HD150L; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: HD150L; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Dark Yellow: Color RGB 168-128-048; Grey: Color RGB 128-128-128; Red: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.05972 m3/s; Pressure Stage: 0; Volume: 0.115 m3; Weight: 140 kg
Type - Mechanical - Flow - Pressure Drop: 19200 Pa
Type - Visibility - Bracket: no; Flange: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HD150L; sets with these values: 2
Other - Bottom Clearance Safe: 1450 mm; Connector Length: 525 mm; Connector Safe: 262.5 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_HD_INT-EN: HD150L; Model Line Width: 525 mm; Top Clearance Safe: 50 mm; Type: HD150L; Type Id: 1982179; Width Service Space: 525 mm
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 3.26545 m2; Maximum Size: 150 mm; Minimum Size: 150 mm; Volume: 0.131312 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - Flow In: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 1450 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
